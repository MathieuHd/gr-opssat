options:
  parameters:
    author: Fischer Benjamin, Mladenov Tom
    description: UHF RX application for offset sampling and doppler compensation (GPredict)
    generate_options: qt_gui
    id: os_uhf_rx
    output_language: python
    title: OPS-SAT UHF RX
  states: {}

blocks:
- name: Squelch
  id: variable_qtgui_range
  parameters:
    start: '-180'
    step: '1'
    stop: '-0'
    value: '-130'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: true_freq - signal_freq
  states: {}
- name: freq_tuned
  id: variable
  parameters:
    value: offset_freq - doppler_freq
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: '-40e3'
  states: {}
- name: rtl_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49.6'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate_down
  id: variable
  parameters:
    value: 57.6e3
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 437.2e6
  states: {}
- name: true_freq
  id: variable
  parameters:
    value: signal_freq
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '25000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mathieu/Documents/gr-opssat/recordings/self.cf32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mathieu/Documents/gr-opssat/recordings/self.cf32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_tuned'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: true_freq
  states: {}
- name: gpredict_doppler_1_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Determined by Gpredict
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Calculated
  states: {}
- name: note_1
  id: note
  parameters:
    note: Satellite frequency
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Offset sampling
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(samp_rate_down)
    taps: ''
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: signal_freq + offset_freq
    freq_correction: '32'
    gain: rtl_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [gpredict_doppler_1_0, freq, blocks_message_debug_0, print]
- [gpredict_doppler_1_0, freq, gpredict_MsgPairToVar_0, inpair]
- [rational_resampler_xxx_0, '0', zeromq_pub_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
