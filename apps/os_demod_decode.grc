options:
  parameters:
    author: Fischer Benjamin, Mladenov Tom
    description: UHF demodulator and decoder application for the ESA OPS-SAT mission
    generate_options: qt_gui
    id: os_demod_decode
    output_language: python
    title: OPS-SAT UHF demodulator/decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian (1.5, 2* (samp_rate / baud_rate) , 0.5, 12)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '57600'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 2 * (samp_rate / baud_rate) /(math.pi)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xFF'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: (samp_rate / baud_rate)*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: gaussian_taps
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: GMSK9k6
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: From RF to bits
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: From bits to frame
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: From frame to payload
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: From payload to stream
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    name: '"OPS-SAT UHF BEACON"'
    showports: 'True'
    type: complex
    update_time: '0.03'
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: DP0OPS
    direction: '"from"'
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '1000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_pdu_head_tail_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '3'
    num: '16'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: hdlc_frame
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    stream_id: tm_fwd
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: hdlc_frame
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: tm_fwd
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:38211
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', virtual_sink_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_0_0_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_descrambler_bb_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [fir_filter_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', zeromq_pub_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_ccsds_0, in]
- [satellites_check_address_0, ok, satellites_pdu_head_tail_0, in]
- [satellites_check_address_0, ok, virtual_sink_0_0_2, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_0, print]
- [satellites_decode_rs_ccsds_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [satellites_hdlc_deframer_0_0, out, virtual_sink_0_0, '0']
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_pdu_head_tail_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', satellites_nrzi_decode_0, '0']
- [virtual_source_0_0, '0', satellites_check_address_0, in]
- [virtual_source_0_0_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [virtual_source_0_0_1, '0', satellites_submit_0, in]
- [zeromq_sub_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
